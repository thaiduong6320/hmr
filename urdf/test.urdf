Commit message: update

File: urdf/test.urdf (robot description, URDF)
Before this commit: robot hmr, 8 links, 7 joints
Joints:
- joint joint: origin (none) -> xyz=0.0 0.0 1.12 rpy=0.0 0.0 0.0
